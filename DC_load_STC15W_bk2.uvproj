# Keil uVision project DC_load_STC15W_bk2.uvproj, settings and files
target DC_load_STC15W (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000)
  output: DC_load_STC15W +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Sources\inc
  link misc: REMOVEUNUSED
  group AiCube
    ./Sources/: main.c port.c clock.c iap.c timer.c uart.c adc.c pwm.c
